# Keil uVision project Demo.uvprojx, settings and files
target Demo (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Demo
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --locale=english
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Hardware\OLED;..\Software\Delay;..\User;..\Software\Menu;..\Hardware\KEY;..\Hardware\Sensor;..\Software\Statistics;..\Hardware\Buzzer;..\ESP_12F;..\Software\Game;..\Hardware\ESP8266;..\Hardware\USART;..\Software\Timestamp;..\Software\ADC;..\Software\DataPackageRx;..\Hardware\DHT11;..\Hardware\GPIO_Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c system_stm32f10x.h stm32f10x.h
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
  group Start
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group User
    ../User/: main.c main.h
  group Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_it.c
  group Delay
    ../Software/Delay/: Delay.c Delay.h
  group OLED
    ../Hardware/OLED/: OLED.c OLED_Data.c OLED.h OLED_Data.h
  group Doc
    ../Doc/: README.txt Statistics_Details.md Chip_Counting_System.md
  group KEY
    ../Hardware/KEY/: Key_multi.c Key_multi.h
  group Menu
    ../Software/Menu/: Menu.c Menu.h MenuFunctions.c MenuFunctions.h Menu_creat.c Menu_creat.h
  group Sensor
    ../Hardware/Sensor/: Sensor.c Sensor.h
  group Statistic
    ../Software/Statistics/: Statistics.c Statistics.h
  group Buzzer
    ../Hardware/Buzzer/: Buzzer.c Buzzer.h
  group USART
    ../Hardware/USART/: USART1.h USART1.c
  group Game
    ../Software/Game/: game_dino_jump.c game_dino_jump.h game_snake.c game_snake.h game_tetris.c game_tetris.h game_flappybird.c game_flappybird.h
  group ESP8266
    ../Hardware/ESP8266/: ESP8266.c ESP8266.h ESP8266Cmd.c ESP8266Cmd.h
  group Timestamp
    ../Software/Timestamp/: Timestamp.c Timestamp.h
  group ADC
    ../Software/ADC/: ADC.h ADC.c
  group DataPackageRx
    ../Software/DataPackageRx/: CYZ_Package.c CYZ_Package.h
  group DHT11
    ../Hardware/DHT11/: DHT11.c DHT11.h
  group MX_GPIO_Config
    ../Hardware/GPIO_Config/: GPIO_Config.c GPIO_Config.h PIN_CONFIG_SUMMARY.c README.md UPDATE_LOG.md
